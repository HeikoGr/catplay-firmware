PACKAGECONFIG = ""

DEPENDS:remove = "openssl"
RDEPENDS:remove = "openssl"

#EXTRA_OECONF:append = " --disable-signature"
