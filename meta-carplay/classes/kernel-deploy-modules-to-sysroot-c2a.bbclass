SYSROOT_DIRS += "/lib/modules"
# do_install:append() {
#     bbwarn "Fixing modules sysroot now"
#     install -d ${D}/lib/modules/${KERNEL_VERSION}
#     cp -r ${B}/lib/modules/${KERNEL_VERSION}/* ${D}/lib/modules/${KERNEL_VERSION}/
# }
