# # Prefer .a variant for hostapd

# EXTRA_OEMAKE:append = 'CC="${CC}" AR="${AR}"'
# do_compile() {
#     oe_runmake -f makefile.unix ${EXTRA_OEMAKE}
# }

# do_install() {
#     oe_runmake -f makefile.unix install
# }
