# Don't pull full OpenSSL
PACKAGECONFIG = "gcrypt"
