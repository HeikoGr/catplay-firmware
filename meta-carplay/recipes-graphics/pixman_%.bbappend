EXTRA_OEMESON:append = " -Ddefault_library=static"
EXTRA_OEMESON:append = " -Db_lto=true"