EXTRA_OECMAKE:append = " -DENABLE_STATIC=TRUE -DENABLE_SHARED=FALSE"
